Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-22T09:52:50
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_XXL280_8x200
Description: 180413_Sherpa_XXL280_8x200

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_XXL280_8x200
Type - PredefinedType: USERDEFINED
Description: XXL280
SHERPA Connection Systems GmbH - Art.-Nr.: 10000025464; Aluminium: EN AW - 5083; Type: XXL280; Number_of_Screws: 54; Locking_Screws: 2; 6x100-55mm: 10000025207; 8.0x200mm: 10000032980; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
