Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-19T08:07:54
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_XL70_8x120
Description: 180413_Sherpa_XL70_8x120

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_XL70_8x120
Type - PredefinedType: USERDEFINED
Description: XL70
SHERPA Connection Systems GmbH - Art.-Nr.: 10000025521; Aluminium: EN AW - 5083; Type: XL70; Number_of_Screws: 21; Locking_Screws: 2; 8.0x120: 10000023936; 6x100-55mm: 10000025207; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
