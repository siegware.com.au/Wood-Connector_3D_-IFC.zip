Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-22T09:45:44
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_XXL250_8x180
Description: 180413_Sherpa_XXL250_8x180

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_XXL250_8x180
Type - PredefinedType: USERDEFINED
Description: XXL250
SHERPA Connection Systems GmbH - Art.-Nr.: 10000025463; Aluminium: EN AW - 5083; Type: XXL250; Number_of_Screws: 52; Locking_Screws: 2; 6x100-55mm: 10000025207; 8.0x180mm: 10000026101; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
