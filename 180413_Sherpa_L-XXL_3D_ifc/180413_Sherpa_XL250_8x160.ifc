Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-20T11:16:56
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_XL250_8x160
Description: 180413_Sherpa_XL250_8x160

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_XL250_8x160
Type - PredefinedType: USERDEFINED
Description: XL250
SHERPA Connection Systems GmbH - Art.-Nr.: 10000025527; Aluminium: EN AW - 5083; Type: XL250; Number_of_Screws: 48; Locking_Screws: 2; 6x100-55mm: 10000025207; 8.0x160mm: 10000021885; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
