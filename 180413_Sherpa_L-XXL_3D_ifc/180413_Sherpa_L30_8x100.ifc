Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-18T18:26:23
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_L30_8x100
Description: 180413_Sherpa_L30_8x100

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_L30_8x100
Type - PredefinedType: USERDEFINED
Description: L30
SHERPA Connection Systems GmbH - Art.-Nr.: 10000025261; Aluminium: EN AW - 6082; Type: L30; Number_of_Screws: 15; Locking_Screws: 2; 8.0x100mm: 10000023937; 5x47.8-20mm: 10000025306; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
