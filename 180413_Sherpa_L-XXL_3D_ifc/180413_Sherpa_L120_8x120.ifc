Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-18T19:01:54
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_L120_8x120
Description: 180413_Sherpa_L120_8x120

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_L120_8x120
Type - PredefinedType: USERDEFINED
Description: L120
SHERPA Connection Systems GmbH - Art.-Nr.: 10000032855; Aluminium: EN AW - 6082; Type: L120; Number_of_Screws: 37; Locking_Screws: 2; 5x47.8-20mm: 10000025306; 8.0x120mm: 10000032978; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
