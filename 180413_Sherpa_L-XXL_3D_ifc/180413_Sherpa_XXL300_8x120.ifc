Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-22T09:59:52
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_XXL300_8x120
Description: 180413_Sherpa_XXL300_8x120

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_XXL300_8x120
Type - PredefinedType: USERDEFINED
Description: XXL300
SHERPA Connection Systems GmbH - Art.-Nr.: 10000025465; Aluminium: EN AW - 5083; Type: XXL300; Number_of_Screws: 59; Locking_Screws: 2; 6x100-55mm: 10000025207; 8.0x120mm: 10000023936; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
