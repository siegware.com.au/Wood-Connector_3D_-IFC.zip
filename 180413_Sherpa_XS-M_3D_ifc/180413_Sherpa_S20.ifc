Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-18T09:53:00
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_S20
Description: 180413_Sherpa_S20

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_S20
Type - PredefinedType: USERDEFINED
Description: S20
SHERPA Connection Systems GmbH - Art.-Nr.: 10000024915; Aluminium: EN AW - 6082; 4.5x50mm: 10000023938; Type: S20; Number_of_Screws: 25; Locking_Screws: 1; 3x20-9mm: 10000025304; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
