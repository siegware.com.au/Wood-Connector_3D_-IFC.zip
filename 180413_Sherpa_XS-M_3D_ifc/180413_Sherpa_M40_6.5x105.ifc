Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-18T10:34:28
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_M40_6.5x105
Description: 180413_Sherpa_M40_6.5x105

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_M40_6.5x105
Type - PredefinedType: USERDEFINED
Description: M40
SHERPA Connection Systems GmbH - Art.-Nr.: 10000024913; Aluminium: EN AW - 6082; Type: M40; Number_of_Screws: 30; Locking_Screws: 1; 4x20-12mm: 10000025305; 6.5x105mm: 10000032977; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
