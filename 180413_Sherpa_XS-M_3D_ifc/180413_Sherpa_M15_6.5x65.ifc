Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-18T10:01:43
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_M15_6.5x65
Description: 180413_Sherpa_M15_6.5x65

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_M15_6.5x65
Type - PredefinedType: USERDEFINED
Description: M15
SHERPA Connection Systems GmbH - Art.-Nr.: 10000025260; Aluminium: EN AW - 6082; Type: M15; Number_of_Screws: 16; Locking_Screws: 1; 6.5x65mm: 10000023616; 4x20-12mm: 10000025305; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
