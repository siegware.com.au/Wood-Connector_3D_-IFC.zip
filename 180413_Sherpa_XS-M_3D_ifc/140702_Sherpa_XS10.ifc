Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-18T09:36:58
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 140702_Sherpa_XS10
Description: 140702_Sherpa_XS10

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 140702_Sherpa_XS10
Type - PredefinedType: USERDEFINED
Description: XS10
SHERPA Connection Systems GmbH - Art.-Nr.: 10000024977; Aluminium: EN AW - 6082; 4.5x50mm: 10000023938; 3x12mm: 10000025303; Type: XS10; Number_of_Screws: 18; Locking_Screws: 1; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
