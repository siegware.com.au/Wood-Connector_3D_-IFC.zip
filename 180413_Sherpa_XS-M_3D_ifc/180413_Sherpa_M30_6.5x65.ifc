Properties of the parts of a building model (IFC2X3)

# File
Time: 2021-03-18T10:26:30
Written by: Processor version 5.1.0.0
Made in: Xbim.IO.MemoryModel

# IfcSite, 180413_Sherpa_M30_6.5x65
Description: 180413_Sherpa_M30_6.5x65

# IfcBuildingElementPart: IfcBuildingElementPart, SHERPA
In: 180413_Sherpa_M30_6.5x65
Type - PredefinedType: USERDEFINED
Description: M30
SHERPA Connection Systems GmbH - Art.-Nr.: 10000023880; Aluminium: EN AW - 6082; Type: M30; Number_of_Screws: 26; Locking_Screws: 1; 6.5x65mm: 10000023616; 4x20-12mm: 10000025305; SHERPA Connection Systems GmbH: SHERPA Connection Systems GmbH
